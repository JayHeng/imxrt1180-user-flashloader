# IAR project flashloader_cm33.ewp, settings and files
configuration release (ARM)
  General.OGChipSelectEditMenu: MIMXRT1189xxx8_M33 NXP MIMXRT1189xxx8_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT1189CVM8C_cm33; CPU_IS_ARM_CORTEX_M33=1; ROM_ENABLE_CMSE; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=0; BL_TARGET_RAM; MIMXRT1189; USB_STACK_BM; PINT_USE_SIMPLE_CALLBACK=1; SDK_DEBUGCONSOLE=1; MIMXRT1189_cm33_SERIES; OSA_USED; DEBUG; USE_RTOS=0
  ICCARM.CCDiagSuppress: Pa082,Pe177,Pe186,Ms014,Pa182
  ICCARM.IExtraOptions: --preinclude ../mcuxsdk_version.h --diag_suppress=Pa082,Pa050
  ICCARM.PreInclude: ../mcux_config.h
  ICCARM.CCIncludePath2: ..; ../../../../xip; ../../../../../../devices/MIMXRT1189/xip; ../../../../../../devices/MIMXRT1189/drivers; ../../../../../../CMSIS/Core/Include; ../../../../../../CMSIS/Core/Include/m-profile; ../../../../../../devices/MIMXRT1189; ../../../../../../devices/MIMXRT1189/periph; ../../../../../../devices/MIMXRT1189/drivers/cm33; ../../../../../../devices/MIMXRT1189/utilities/debug_console_lite; ../../../../../../components/lists; ../../../../../../devices/MIMXRT1189/utilities/str; ../../../../../../components/silicon_id; ../../../../../../components/silicon_id/socs; ../../../../../../components/uart; ../../../../../../components/osa; ../../../../../../middleware/usb/include; ../../../../../../middleware/usb/phy; ../../../../../../middleware/mcu_bootloader/src/autobaud; ../../../../../../middleware/mcu_bootloader/src/bootloader; ../../../../../../middleware/mcu_bootloader/src/crc; ../../../../../../middleware/mcu_bootloader/src/include; ../../../../../../middleware/mcu_bootloader/src/memory; ../../../../../../middleware/mcu_bootloader/src/memory/src; ../../../../../../middleware/mcu_bootloader/src/packet; ../../../../../../middleware/mcu_bootloader/src/property; ../../../../../../middleware/mcu_bootloader/src/sbloader; ../../../../../../middleware/mcu_bootloader/src/utilities; ../../../../../../middleware/mcu_bootloader/src/startup; ../../../../../../middleware/usb/device; ../../../../../../middleware/usb/device/class; ../../../../../../middleware/mcu_bootloader/src/bm_usb; ../../../../../../middleware/mcu_bootloader/src/drivers/serial_nor_eeprom; ../../../../../../middleware/mcu_bootloader/src/drivers/usdhc; ../../../../../../middleware/mcu_bootloader/src/drivers/sdmmc/inc; ../../../../../../middleware/mcu_bootloader/src/drivers/semc; ../../../../../../middleware/mcu_bootloader/src/drivers/semc_nand; ../../../../../../middleware/mcu_bootloader/src/drivers/nand_ecc; ../../../../../../middleware/mcu_bootloader/src/drivers/flexspi; ../../../../../../middleware/mcu_bootloader/src/drivers/flexspi_nor; ../../../../../../middleware/mcu_bootloader/src/drivers/flexspi_nand; ../../../../../../middleware/mcu_bootloader/src/drivers/microseconds; ../../../../../../middleware/mcu_bootloader/src/drivers/edgelock; ../../../../../../middleware/mcu_bootloader/targets/MIMXRT1189/src; ../../../../../../middleware/mcu_bootloader/src/security/keyblob; ../../../../../../middleware/mcu_bootloader/src; ../../../../../../middleware/mcu_bootloader/src/drivers
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: CPU_MIMXRT1189CVM8C_cm33; MIMXRT1189_cm33_SERIES; OSA_USED; DEBUG; NDEBUG
  AARM.AUserIncludes: ..; ../../../../xip; ../../../../../../devices/MIMXRT1189/xip; ../../../../../../devices/MIMXRT1189/drivers; ../../../../../../CMSIS/Core/Include; ../../../../../../CMSIS/Core/Include/m-profile; ../../../../../../devices/MIMXRT1189; ../../../../../../devices/MIMXRT1189/periph; ../../../../../../devices/MIMXRT1189/drivers/cm33; ../../../../../../devices/MIMXRT1189/utilities/debug_console_lite; ../../../../../../components/lists; ../../../../../../devices/MIMXRT1189/utilities/str; ../../../../../../components/silicon_id; ../../../../../../components/silicon_id/socs; ../../../../../../components/uart; ../../../../../../components/osa; ../../../../../../middleware/usb/include; ../../../../../../middleware/usb/phy; ../../../../../../middleware/mcu_bootloader/src/startup; ../../../../../../middleware/mcu_bootloader/src/autobaud; ../../../../../../middleware/mcu_bootloader/src/bootloader; ../../../../../../middleware/mcu_bootloader/src/crc; ../../../../../../middleware/mcu_bootloader/src/include; ../../../../../../middleware/mcu_bootloader/src/memory; ../../../../../../middleware/mcu_bootloader/src/memory/src; ../../../../../../middleware/mcu_bootloader/src/packet; ../../../../../../middleware/mcu_bootloader/src/property; ../../../../../../middleware/mcu_bootloader/src/sbloader; ../../../../../../middleware/mcu_bootloader/src/utilities; ../../../../../../middleware/usb/device; ../../../../../../middleware/usb/device/class; ../../../../../../middleware/mcu_bootloader/src/bm_usb; ../../../../../../middleware/mcu_bootloader/src/drivers/serial_nor_eeprom; ../../../../../../middleware/mcu_bootloader/src/drivers/usdhc; ../../../../../../middleware/mcu_bootloader/src/drivers/sdmmc/inc; ../../../../../../middleware/mcu_bootloader/src/drivers/semc; ../../../../../../middleware/mcu_bootloader/src/drivers/semc_nand; ../../../../../../middleware/mcu_bootloader/src/drivers/nand_ecc; ../../../../../../middleware/mcu_bootloader/src/drivers/flexspi; ../../../../../../middleware/mcu_bootloader/src/drivers/flexspi_nor; ../../../../../../middleware/mcu_bootloader/src/drivers/flexspi_nand; ../../../../../../middleware/mcu_bootloader/src/drivers/microseconds; ../../../../../../middleware/mcu_bootloader; ../../../../../../middleware/mcu_bootloader/src/drivers/edgelock; ../../../../../../middleware/mcu_bootloader/targets/MIMXRT1189/src; ../../../../../../middleware/mcu_bootloader/src/security/keyblob; ../../../../../../middleware/mcu_bootloader/src; ../../../../../../middleware/mcu_bootloader/src/drivers
  AARM.PreInclude: ../mcux_config.h
  OBJCOPY.OOCOutputFile: flashloader.bin
  ILINK.IlinkOutputFile: flashloader_cm33.out
  ILINK.IlinkIcfFile: MIMXRT1189_ram_flashloader.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group board
    ../: board.c board.h clock_config.c clock_config.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_version.h core_cm33.h tz_context.h
  group CMSIS/m-profile
    ../../../../../../CMSIS/Core/Include/m-profile/: armv8m_mpu.h cmsis_iccarm_m.h
  group component
    ../../../../../../components/silicon_id/socs/: fsl_silicon_id_soc.h
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group component/osa
    ../../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_bm.c fsl_os_abstraction_bm.h
  group component/silicon_id
    ../../../../../../components/silicon_id/: fsl_silicon_id.c fsl_silicon_id.h
    ../../../../../../components/silicon_id/socs/imxrt1180/: fsl_silicon_id_soc.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group device
    ../../../../../../devices/MIMXRT1189/: fsl_device_registers.h MIMXRT1189_cm33.h MIMXRT1189_cm33_COMMON.h MIMXRT1189_cm33_features.h
  group device/periph
    ../../../../../../devices/MIMXRT1189/periph/: PERI_ADC.h PERI_ANADIG.h PERI_ANADIG_LDO_BBSM.h PERI_ANADIG_MISC.h PERI_ANADIG_OSC.h PERI_ANADIG_PLL.h PERI_ANADIG_PMU.h PERI_ANADIG_TEMPSENSOR.h PERI_AOI.h PERI_ASRC.h PERI_AXBS.h PERI_BBNSM.h PERI_BLK_CTRL_BBSMMIX.h PERI_BLK_CTRL_NS_AONMIX.h PERI_BLK_CTRL_S_AONMIX.h PERI_BLK_CTRL_WAKEUPMIX.h PERI_CACHE_ECC_MCM.h PERI_CAN.h PERI_CCM.h PERI_CMP.h PERI_DAC.h PERI_DCDC.h PERI_DMA.h PERI_DMA4.h PERI_ECAT.h PERI_EIM.h PERI_ENETC_GLOBAL.h PERI_ENETC_PCI_TYPE0.h PERI_ENETC_PF_EMDIO.h PERI_ENETC_PF_TMR.h PERI_ENETC_SI.h PERI_ENETC_VF_PCI_TYPE0.h PERI_EQDC.h PERI_ERM.h PERI_EWM.h PERI_FLEXIO.h PERI_FLEXSPI.h PERI_FLEXSPI_SLV.h PERI_GPC_CPU_CTRL.h PERI_GPC_GLOBAL.h PERI_GPC_SYS_SLEEP_CTRL.h PERI_GPT.h PERI_I2S.h PERI_I3C.h PERI_IEE.h PERI_IEE_APC.h PERI_IERC_IERB.h PERI_IERC_PCI.h PERI_IOMUXC.h PERI_IOMUXC_AON.h PERI_KPP.h PERI_LPI2C.h PERI_LPIT.h PERI_LPSPI.h PERI_LPTMR.h PERI_LPUART.h PERI_M7_MCM.h PERI_MECC.h PERI_MSGINTR.h PERI_MU.h PERI_NETC_ENETC.h PERI_NETC_ETH_LINK.h PERI_NETC_IERB.h PERI_NETC_PORT.h PERI_NETC_PRIV.h PERI_NETC_PSEUDO_LINK.h PERI_NETC_SW.h PERI_NETC_SW_ENETC.h PERI_OCOTP_FSB.h PERI_OSC_RC_400M.h PERI_OTFAD.h PERI_PDM.h PERI_PHY_LDO.h PERI_PLL.h PERI_PWM.h PERI_RGPIO.h PERI_RTWDOG.h PERI_S3MU.h PERI_SEMA42.h PERI_SEMC.h PERI_SINC.h PERI_SPDIF.h PERI_SRC_GENERAL.h PERI_SRC_MIF_LN28FDSOI_SPLLRAM.h PERI_SRC_MIF_S28SPREGH.h PERI_SRC_MIF_S28SPREGH_PSWA.h PERI_SRC_MIX_SLICE.h PERI_SYS_CTR_COMPARE.h PERI_SYS_CTR_CONTROL.h PERI_SYS_CTR_READ.h PERI_SYSPM.h PERI_TCM_ECC_MCM.h PERI_TMPSNS.h PERI_TMR.h PERI_TPM.h PERI_TRDC.h PERI_TSTMR.h PERI_USB.h PERI_USBHSDCD.h PERI_USBNC.h PERI_USBPHY.h PERI_USDHC.h PERI_VMBANDGAP.h PERI_VREF.h PERI_XBAR_NUM_OUT221.h PERI_XBAR_NUM_OUT32.h PERI_XCACHE.h
  group drivers
    ../../../../../../devices/MIMXRT1189/drivers/cm33/: fsl_cache.c fsl_cache.h
    ../../../../../../devices/MIMXRT1189/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_dcdc.c fsl_dcdc.h fsl_ele_base_api.c fsl_ele_base_api.h fsl_gpc.c fsl_gpc.h fsl_iomuxc.h fsl_lpspi.c fsl_lpspi.h fsl_lpuart.c fsl_lpuart.h fsl_memory.c fsl_memory.h fsl_misc.h fsl_pmu.c fsl_pmu.h fsl_rgpio.c fsl_rgpio.h fsl_s3mu.c fsl_s3mu.h fsl_soc_src.c fsl_soc_src.h fsl_trdc.c fsl_trdc.h
  group mcu_bootloader
    ../../../../../../devices/RT/RT1180/MIMXRT1189/: system_MIMXRT1189_cm33.h
  group mcu_bootloader/targets/MIMXRT1189/src/startup
    ../../../../../../middleware/mcu_bootloader/targets/MIMXRT1189/src/startup/: system_MIMXRT1189_cm33.c
  group mcu_bootloader/targets/MIMXRT1189/src/startup/iar
    ../../../../../../middleware/mcu_bootloader/targets/MIMXRT1189/src/startup/iar/: startup_MIMXRT1189_cm33.s
  group source
    ../: fsl_os_abstraction_config.h mcux_config.h mcuxsdk_version.h pin_mux.c pin_mux.h
  group source/src/autobaud
    ../../../../../../middleware/mcu_bootloader/src/autobaud/: autobaud.h
  group source/src/autobaud/src
    ../../../../../../middleware/mcu_bootloader/src/autobaud/src/: autobaud_irq.c
  group source/src/bm_usb
    ../../../../../../middleware/mcu_bootloader/src/bm_usb/: bootloader_hid_report_ids.h composite.c composite.h fat_directory_entry.h hid_bootloader.c hid_bootloader.h usb_descriptor.c usb_descriptor.h
  group source/src/bootloader
    ../../../../../../middleware/mcu_bootloader/src/bootloader/: bl_app_crc_check.h bl_command.h bl_context.h bl_irq_common.h bl_keyblob.h bl_peripheral.h bl_peripheral_interface.h bl_shutdown_cleanup.h bl_user_entry.h bl_version.h bootloader.h
  group source/src/bootloader/src
    ../../../../../../middleware/mcu_bootloader/src/bootloader/src/: bl_app_crc_check.c bl_command.c bl_context.c bl_exception_handler.c bl_main.c bl_misc.c bl_shutdown_cleanup.c bl_tree_root.c bl_user_entry.c lpspi_peripheral_interface.c lpuart_peripheral_interface.c usb_hid_msc_peripheral_interface.c
  group source/src/crc
    ../../../../../../middleware/mcu_bootloader/src/crc/: crc16.h crc32.h
  group source/src/crc/src
    ../../../../../../middleware/mcu_bootloader/src/crc/src/: crc16.c crc32.c
  group source/src/drivers/edgelock
    ../../../../../../middleware/mcu_bootloader/src/drivers/edgelock/: fsl_edgelock.c fsl_edgelock.h
  group source/src/drivers/flexspi
    ../../../../../../middleware/mcu_bootloader/src/drivers/flexspi/: bl_flexspi.c bl_flexspi.h
  group source/src/drivers/flexspi_nand
    ../../../../../../middleware/mcu_bootloader/src/drivers/flexspi_nand/: flexspi_nand_flash.c flexspi_nand_flash.h
  group source/src/drivers/flexspi_nor
    ../../../../../../middleware/mcu_bootloader/src/drivers/flexspi_nor/: flexspi_nor_flash.c flexspi_nor_flash.h
  group source/src/drivers/microseconds
    ../../../../../../middleware/mcu_bootloader/src/drivers/microseconds/: microseconds.h
  group source/src/drivers/microseconds/src
    ../../../../../../middleware/mcu_bootloader/src/drivers/microseconds/src/: microseconds_lpit.c
  group source/src/drivers/nand_ecc
    ../../../../../../middleware/mcu_bootloader/src/drivers/nand_ecc/: nand_ecc.c nand_ecc.h
  group source/src/drivers/sdmmc/inc
    ../../../../../../middleware/mcu_bootloader/src/drivers/sdmmc/inc/: fsl_mmc.h fsl_sd.h fsl_sdmmc_common.h fsl_sdmmc_host.h fsl_sdmmc_spec.h
  group source/src/drivers/sdmmc/port/usdhc/polling
    ../../../../../../middleware/mcu_bootloader/src/drivers/sdmmc/port/usdhc/polling/: fsl_sdmmc_host.c
  group source/src/drivers/sdmmc/src
    ../../../../../../middleware/mcu_bootloader/src/drivers/sdmmc/src/: fsl_mmc.c fsl_sd.c fsl_sdmmc_common.c
  group source/src/drivers/semc
    ../../../../../../middleware/mcu_bootloader/src/drivers/semc/: bl_semc.c bl_semc.h
  group source/src/drivers/semc_nand
    ../../../../../../middleware/mcu_bootloader/src/drivers/semc_nand/: semc_nand_flash.c semc_nand_flash.h
  group source/src/drivers/serial_nor_eeprom
    ../../../../../../middleware/mcu_bootloader/src/drivers/serial_nor_eeprom/: serial_nor_eeprom.c serial_nor_eeprom.h
  group source/src/drivers/usdhc
    ../../../../../../middleware/mcu_bootloader/src/drivers/usdhc/: bl_usdhc.c bl_usdhc.h
  group source/src/include
    ../../../../../../middleware/mcu_bootloader/src/include/: bootloader_common.h bootloader_core.h
  group source/src/memory
    ../../../../../../middleware/mcu_bootloader/src/memory/: memory.h
  group source/src/memory/src
    ../../../../../../middleware/mcu_bootloader/src/memory/src/: flexspi_nor_memory.c flexspi_nor_memory.h memory.c mmc_memory.c mmc_memory.h normal_memory.c normal_memory.h pattern_fill.h pattern_fill.s sd_memory.c sd_memory.h semc_nand_memory.c semc_nand_memory.h spi_nor_eeprom_memory.c spi_nor_eeprom_memory.h spinand_memory.c spinand_memory.h sram_init.h
  group source/src/packet
    ../../../../../../middleware/mcu_bootloader/src/packet/: command_packet.h serial_packet.h
  group source/src/packet/src
    ../../../../../../middleware/mcu_bootloader/src/packet/src/: serial_packet.c
  group source/src/property
    ../../../../../../middleware/mcu_bootloader/src/property/: property.h
  group source/src/property/src
    ../../../../../../middleware/mcu_bootloader/src/property/src/: property_imx.c
  group source/src/sbloader
    ../../../../../../middleware/mcu_bootloader/src/sbloader/: sb_file_format.h sbloader.h
  group source/src/sbloader/src
    ../../../../../../middleware/mcu_bootloader/src/sbloader/src/: sbloader.c
  group source/src/security/keyblob
    ../../../../../../middleware/mcu_bootloader/src/security/keyblob/: keyblob.h
  group source/src/security/keyblob/src
    ../../../../../../middleware/mcu_bootloader/src/security/keyblob/src/: keyblob.c keyblob_edgelock.c
  group source/src/startup
    ../../../../../../middleware/mcu_bootloader/src/startup/: startup.c
  group source/src/utilities
    ../../../../../../middleware/mcu_bootloader/src/utilities/: fsl_assert.h fsl_rtos_abstraction.h vector_table_info.h
  group source/src/utilities/src
    ../../../../../../middleware/mcu_bootloader/src/utilities/src/: debug_util.c fsl_assert.c fsl_rtos_abstraction.c
  group source/targets/common/src
    ../../../../../../middleware/mcu_bootloader/targets/common/src/: pinmux_utility_imxrt_series.c
  group source/targets/MIMXRT1189/src
    ../../../../../../middleware/mcu_bootloader/targets/MIMXRT1189/src/: bl_lpspi_irq_config_MIMXRT1189.c bl_lpuart_irq_config_MIMXRT1189.c bootloader_config.h clock_cfg_MIMXRT1189.c edgelock_config_MIMXRT1189.c external_memory_property_map_MIMXRT1189.c flexspi_config_MIMXRT1189.c flexspi_nand_config_MIMXRT1189.c flexspi_nor_config_MIMXRT1189.c fusemap.h hardware_init_MIMXRT1189.c lpspi_mem_config_MIMXRT1189.c memory_config.h memory_map_MIMXRT1189.c periph_MIMXRT1189.c peripherals_pinmux.h sdmmc_config_MIMXRT1189.c sdmmc_convert_MIMXRT1189.c sdmmc_init.h semc_nand_config_MIMXRT1189.c sram_init_MIMXRT1189.c target_config.h usb_device_config.h
  group usb
    ../../../../../../middleware/usb/: ChangeLogKSDK.txt
  group usb/device
    ../../../../../../middleware/usb/device/: usb_device.h usb_device_ch9.c usb_device_ch9.h usb_device_dci.c usb_device_dci.h usb_device_ehci.c usb_device_ehci.h
  group usb/device/class
    ../../../../../../middleware/usb/device/class/: usb_device_class.c usb_device_class.h usb_device_hid.c usb_device_hid.h
  group usb/include
    ../../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group usb/phy
    ../../../../../../middleware/usb/phy/: usb_phy.c usb_phy.h
  group utilities
    ../../../../../../devices/MIMXRT1189/utilities/debug_console_lite/: fsl_assert.c fsl_assert.h
  group utilities/debug_console_lite
    ../../../../../../devices/MIMXRT1189/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h
  group utilities/str
    ../../../../../../devices/MIMXRT1189/utilities/str/: fsl_str.c fsl_str.h
  group xip
    ../../../../xip/: evkmimxrt1180_flexspi_nor_config.c evkmimxrt1180_flexspi_nor_config.h
    ../../../../../../devices/MIMXRT1189/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
